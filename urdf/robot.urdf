Commit message: Ensure proper coordinate frame transformations

File: urdf/robot.urdf (robot description, URDF)
Before this commit: robot two_link_arm, 4 links, 3 joints
Joints:
- joint joint1: origin xyz=0 0 0.1 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
